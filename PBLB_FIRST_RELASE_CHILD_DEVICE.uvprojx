# Keil uVision project PBLB_FIRST_RELASE_CHILD_DEVICE.uvprojx, settings and files
target PBLB_FIRST_RELASE_CHILD_DEVICE (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.3.2
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: PBLB_FIRST_RELASE_CHILD_DEVICE
  c flags: Optim=2 uC99=1
  c misc: -DTARGET_NRF_32MHZ_XTAL -DDEVICE_RTC=1 -DDEVICE_SLEEP=1 -DTOOLCHAIN_object -DTARGET_MCU_NRF51822 -DTARGET_NRF5 --preinclude=mbed_config.h -DTARGET_MCU_NRF51822_UNIFIED -DTARGET_MCU_NRF51_32K -D__ASSERT_MSG -DTARGET_MCU_NORDIC_32K -DTARGET_NRF51822 --no_rtti -DS130 -Otime -DDEVICE_PORTINOUT=1 -DSOFTDEVICE_PRESENT -DDEVICE_I2C_ASYNCH=1 -c -DTARGET_NORDIC -O3 -DDEVICE_SPISLAVE=1 -DDEVICE_PORTOUT=1 -DTARGET_RELEASE --split_sections -DTARGET_LIKE_CORTEX_M0 -DARM_MATH_CM0 -DDEVICE_ANALOGIN=1 -DDEVICE_PORTIN=1 -DTARGET_CORTEX_M -DDEVICE_ERROR_PATTERN=1 -DMBED_BUILD_TIMESTAMP=1479194953.06 --cpu=Cortex-M0 -DDEVICE_I2C=1 -DBLE_STACK_SUPPORT_REQD -DTARGET_TY51822R3 -DDEVICE_LOWPOWERTIMER=1 -DTOOLCHAIN_ARM -D__CORTEX_M0 -DNRF51 -DTOOLCHAIN_ARM_STD --no_depend_system_headers -DTARGET_UVISOR_UNSUPPORTED --md -DDEVICE_PWMOUT=1 -DDEVICE_SERIAL_ASYNCH=1 --gnu -DTARGET_MCU_NRF51 --apcs=interwork -DDEVICE_SPI=1 -D__MBED__=1 -DDEVICE_SERIAL=1 -DTARGET_M0 -DDEVICE_INTERRUPTIN=1 -D__CMSIS_RTOS -DDEVICE_SPI_ASYNCH=1 -DFEATURE_BLE=1 -D__MBED_CMSIS_RTOS_CM -DTARGET_LIKE_MBED
  c include: .; BLE_API; BLE_API/ble; BLE_API/ble/services; BLE_API/source; BLE_API/source/services; SDFileSystem; SDFileSystem/FATFileSystem; SDFileSystem/FATFileSystem/ChaN; mbed-rtos; mbed-rtos/rtos; mbed-rtos/rtx; mbed-rtos/rtx/TARGET_CORTEX_M; mbed-rtos/rtx/TARGET_CORTEX_M/TARGET_M0; mbed-rtos/rtx/TARGET_CORTEX_M/TARGET_M0/TOOLCHAIN_ARM; nRF51822; nRF51822/TARGET_NRF5; nRF51822/TARGET_NRF5/source; nRF51822/TARGET_NRF5/source/btle; nRF51822/TARGET_NRF5/source/btle/custom; nRF51822/TARGET_NRF5/source/common; mbed/.; mbed/TARGET_TY51822R3; mbed/TARGET_TY51822R3/TARGET_NORDIC; mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5; mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF51822_UNIFIED; mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF51822_UNIFIED/TARGET_TY51822R3; mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF51822_UNIFIED/sdk; mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF51822_UNIFIED/sdk/drivers_nrf; mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF51822_UNIFIED/sdk/drivers_nrf/adc; mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF51822_UNIFIED/sdk/softdevice; mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF51822_UNIFIED/sdk/softdevice/s130; mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF51822_UNIFIED/sdk/softdevice/s130/headers; mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF51822_UNIFIED/sdk/softdevice/s130/headers/nrf51; mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF51822_UNIFIED/sdk/softdevice/s130/hex; mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk; mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/ble; mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/ble/ble_advertising; mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/ble/ble_db_discovery; mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/ble/ble_debug_assert_handler; mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/ble/ble_dtm; mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/ble/ble_error_log; mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/ble/ble_racp; mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/ble/ble_radio_notification; mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/ble/ble_services; mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/ble/ble_services/ble_dfu; mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/ble/common; mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/ble/device_manager; mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/ble/device_manager/config; mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/ble/peer_manager; mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/drivers_nrf; mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/drivers_nrf/ble_flash; mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/drivers_nrf/clock; mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/drivers_nrf/common; mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/drivers_nrf/config; mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/drivers_nrf/delay; mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/drivers_nrf/gpiote; mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/drivers_nrf/hal; mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/drivers_nrf/ppi; mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/drivers_nrf/pstorage; mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/drivers_nrf/pstorage/config; mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/drivers_nrf/spi_master; mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/drivers_nrf/spi_slave; mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/drivers_nrf/timer; mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/drivers_nrf/twi_master; mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/libraries; mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/libraries/bootloader_dfu; mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/libraries/bootloader_dfu/hci_transport; mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/libraries/crc16; mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/libraries/experimental_section_vars; mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/libraries/fds; mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/libraries/fds/config; mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/libraries/fstorage; mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/libraries/fstorage/config; mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/libraries/hci; mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/libraries/hci/config; mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/libraries/pwm; mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/libraries/scheduler; mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/libraries/trace; mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/libraries/util; mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/softdevice; mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/softdevice/common; mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/softdevice/common/softdevice_handler; mbed/TARGET_TY51822R3/TOOLCHAIN_ARM_STD;
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-DTARGET_MCU_NRF51822,-DBLE_STACK_SUPPORT_REQD,-DARM_MATH_CM0,-D__MBED_CMSIS_RTOS_CM,-DTARGET_MCU_NRF51_32K,-DNRF51,-D__CORTEX_M0,-DTARGET_NRF51822,-DTARGET_MCU_NORDIC_32K,-D__CMSIS_RTOS,-DS130,-DSOFTDEVICE_PRESENT,-DTARGET_NRF_32MHZ_XTAL
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: mbed/TARGET_TY51822R3/TOOLCHAIN_ARM_STD/nRF51822.sct
  group ChaN
    SDFileSystem/FATFileSystem/ChaN/: ccsbcs.cpp diskio.cpp diskio.h ff.cpp ff.h ffconf.h integer.h
  group FATFileSystem
    SDFileSystem/FATFileSystem/: FATDirHandle.cpp FATDirHandle.h FATFileHandle.cpp FATFileHandle.h FATFileSystem.cpp FATFileSystem.h MemFileSystem.h
  group PBLB_FIRST_RELASE_CHILD_DEVICE
    ./: main.cpp mbed_config.h
  group SDFileSystem
    SDFileSystem/: SDCRC.cpp SDCRC.h SDFileSystem.cpp SDFileSystem.h
  group TARGET_CORTEX_M
    mbed-rtos/rtx/TARGET_CORTEX_M/: cmsis_os.h HAL_CM.c rt_CMSIS.c rt_Event.c rt_Event.h rt_HAL_CM.h rt_List.c rt_List.h rt_Mailbox.c rt_Mailbox.h rt_MemBox.c rt_MemBox.h rt_Memory.c rt_Memory.h rt_Mutex.c rt_Mutex.h rt_OsEventObserver.c rt_OsEventObserver.h rt_Robin.c rt_Robin.h rt_Semaphore.c rt_Semaphore.h rt_System.c rt_System.h rt_Task.c rt_Task.h rt_Time.c rt_Time.h rt_Timer.c rt_Timer.h rt_TypeDef.h RTX_CM_lib.h RTX_Conf_CM.c RTX_Config.h
  group TARGET_MCU_NRF51822_UNIFIED
    mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF51822_UNIFIED/: PeripheralNames.h PortNames.h
  group TARGET_NRF5
    mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/: common_rtc.h gpio_object.h objects.h
  group TARGET_TY51822R3
    mbed/TARGET_TY51822R3/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis.h cmsis_nvic.h compiler_abstraction.h core_ca9.h core_ca_mmu.h core_caFunc.h core_caInstr.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSecureAccess.h core_cmSimd.h core_sc000.h core_sc300.h nrf.h nrf51.h nrf51_bitfields.h nrf51_deprecated.h nrf51_to_nrf52.h nrf52.h nrf52_bitfields.h nrf52_name_change.h nrf5x_lf_clk_helper.h system_nrf51.h
    mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF51822_UNIFIED/TARGET_TY51822R3/: device.h PinNames.h
  group TOOLCHAIN_ARM
    mbed-rtos/rtx/TARGET_CORTEX_M/TARGET_M0/TOOLCHAIN_ARM/: HAL_CM0.c SVC_Table.S
  group TOOLCHAIN_ARM_STD
    mbed/TARGET_TY51822R3/TOOLCHAIN_ARM_STD/: cmsis_nvic.o mbed.ar mbed_board.o retarget.o startup_nRF51822.o sys.o system_nrf51.o
  group adc
    mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF51822_UNIFIED/sdk/drivers_nrf/adc/: nrf_drv_adc.h
  group ble
    BLE_API/ble/: BLE.h blecommon.h BLEInstanceBase.h BLEProtocol.h CallChainOfFunctionPointersWithContext.h CharacteristicDescriptorDiscovery.h deprecate.h DiscoveredCharacteristic.h DiscoveredCharacteristicDescriptor.h DiscoveredService.h FunctionPointerWithContext.h Gap.h GapAdvertisingData.h GapAdvertisingParams.h GapEvents.h GapScanningParams.h GattAttribute.h GattCallbackParamTypes.h GattCharacteristic.h GattClient.h GattServer.h GattServerEvents.h GattService.h SafeBool.h SecurityManager.h ServiceDiscovery.h UUID.h
  group ble_advertising
    mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/ble/ble_advertising/: ble_advertising.h
  group ble_db_discovery
    mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/ble/ble_db_discovery/: ble_db_discovery.h
  group ble_debug_assert_handler
    mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/ble/ble_debug_assert_handler/: ble_debug_assert_handler.h
  group ble_dfu
    mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/ble/ble_services/ble_dfu/: ble_dfu.h
  group ble_dtm
    mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/ble/ble_dtm/: ble_dtm.h
  group ble_error_log
    mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/ble/ble_error_log/: ble_error_log.h
  group ble_flash
    mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/drivers_nrf/ble_flash/: ble_flash.h
  group ble_racp
    mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/ble/ble_racp/: ble_racp.h
  group ble_radio_notification
    mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/ble/ble_radio_notification/: ble_radio_notification.h
  group bootloader_dfu
    mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/libraries/bootloader_dfu/: bootloader.h bootloader_settings.h bootloader_types.h bootloader_util.h dfu.h dfu_app_handler.h dfu_bank_internal.h dfu_ble_svc.h dfu_ble_svc_internal.h dfu_init.h dfu_transport.h dfu_types.h
  group btle
    nRF51822/TARGET_NRF5/source/btle/: btle.cpp btle.h btle_advertising.cpp btle_advertising.h btle_clock.h btle_discovery.cpp btle_discovery.h btle_gap.cpp btle_gap.h btle_security.cpp btle_security.h
  group clock
    mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/drivers_nrf/clock/: nrf_drv_clock.h
  group common
    nRF51822/TARGET_NRF5/source/common/: ansi_escape.h assertion.h binary.h ble_error.h common.h compiler.h
    mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/ble/common/: ble_advdata.h ble_conn_params.h ble_conn_state.h ble_date_time.h ble_gatt_db.h ble_sensor_location.h ble_srv_common.h
    mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/drivers_nrf/common/: nrf_drv_common.h
  group config
    mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/ble/device_manager/config/: device_manager_cnfg.h
    mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/libraries/fds/config/: fds_config.h
    mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/libraries/fstorage/config/: fstorage_config.h
    mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/libraries/hci/config/: hci_mem_pool_internal.h hci_transport_config.h
    mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/drivers_nrf/config/: nrf_drv_config_validation.h
    mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/drivers_nrf/pstorage/config/: pstorage_platform.h
  group crc16
    mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/libraries/crc16/: crc16.h
  group custom
    nRF51822/TARGET_NRF5/source/btle/custom/: custom_helper.cpp custom_helper.h
  group delay
    mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/drivers_nrf/delay/: nrf_delay.h
  group device_manager
    mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/ble/device_manager/: device_manager.h
  group experimental_section_vars
    mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/libraries/experimental_section_vars/: section_vars.h
  group fds
    mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/libraries/fds/: fds.h fds_internal_defs.h
  group fstorage
    mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/libraries/fstorage/: fstorage.h fstorage_internal_defs.h
  group gpiote
    mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/drivers_nrf/gpiote/: nrf_drv_gpiote.h
  group hal
    mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/drivers_nrf/hal/: nrf_adc.h nrf_clock.h nrf_ecb.h nrf_gpio.h nrf_gpiote.h nrf_nvmc.h nrf_pdm.h nrf_ppi.h nrf_pwm.h nrf_rtc.h nrf_saadc.h nrf_spi.h nrf_spim.h nrf_spis.h nrf_temp.h nrf_timer.h nrf_twi.h nrf_uart.h nrf_wdt.h
  group hci
    mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/libraries/hci/: hci_mem_pool.h
  group hci_transport
    mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/libraries/bootloader_dfu/hci_transport/: hci_mem_pool_internal.h hci_transport_config.h
  group headers
    mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF51822_UNIFIED/sdk/softdevice/s130/headers/: nrf_ble.h nrf_ble_err.h nrf_ble_gap.h nrf_ble_gatt.h nrf_ble_gattc.h nrf_ble_gatts.h nrf_ble_hci.h nrf_ble_l2cap.h nrf_ble_ranges.h nrf_ble_types.h nrf_error.h nrf_error_sdm.h nrf_error_soc.h nrf_nvic.h nrf_sd_def.h nrf_sdm.h nrf_soc.h nrf_svc.h
  group mbed
    mbed/: AnalogIn.h analogin_api.h AnalogOut.h analogout_api.h buffer.h BusIn.h BusInOut.h BusOut.h Callback.h CallChain.h CAN.h can_api.h can_helper.h CircularBuffer.h critical.h CThunk.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h dma_api.h Driver_Common.h Driver_Storage.h Ethernet.h ethernet_api.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemLike.h FunctionPointer.h gpio_api.h gpio_irq_api.h I2C.h i2c_api.h I2CSlave.h InterruptIn.h InterruptManager.h LocalFileSystem.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h lp_ticker_api.h mbed.h mbed_assert.h mbed_debug.h mbed_error.h mbed_interface.h mbed_mem_trace.h mbed_stats.h pinmap.h platform.h PlatformMutex.h port_api.h PortIn.h PortInOut.h PortOut.h PwmOut.h pwmout_api.h RawSerial.h rtc_api.h rtc_time.h semihost_api.h Serial.h serial_api.h SerialBase.h SingletonPtr.h sleep_api.h SPI.h spi_api.h SPISlave.h Stream.h Ticker.h ticker_api.h Timeout.h Timer.h TimerEvent.h toolchain.h Transaction.h us_ticker_api.h wait_api.h
  group nrf51
    mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF51822_UNIFIED/sdk/softdevice/s130/headers/nrf51/: nrf_mbr.h
  group peer_manager
    mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/ble/peer_manager/: gatt_cache_manager.h gattc_cache_manager.h gatts_cache_manager.h id_manager.h peer_data.h peer_data_storage.h peer_database.h peer_id.h peer_manager.h peer_manager_internal.h peer_manager_types.h pm_buffer.h pm_mutex.h security_dispatcher.h security_manager.h
  group ppi
    mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/drivers_nrf/ppi/: nrf_drv_ppi.h
  group pstorage
    mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/drivers_nrf/pstorage/: pstorage.h
  group pwm
    mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/libraries/pwm/: app_pwm.h
  group rtos
    mbed-rtos/rtos/: Mail.h MemoryPool.h Mutex.cpp Mutex.h Queue.h rtos.h rtos_idle.c rtos_idle.h RtosTimer.cpp RtosTimer.h Semaphore.cpp Semaphore.h Thread.cpp Thread.h
  group scheduler
    mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/libraries/scheduler/: app_scheduler.h
  group sdk
    mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/TARGET_MCU_NRF51822_UNIFIED/sdk/: nrf_drv_config.h
  group services
    BLE_API/ble/services/: BatteryService.h DeviceInformationService.h DFUService.h EddystoneConfigService.h EddystoneService.h EnvironmentalService.h HealthThermometerService.h HeartRateService.h iBeacon.h LinkLossService.h UARTService.h URIBeaconConfigService.h
    BLE_API/source/services/: DFUService.cpp UARTService.cpp URIBeaconConfigService.cpp
  group softdevice_handler
    mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/softdevice/common/softdevice_handler/: ant_stack_handler_types.h app_ram_base.h ble_stack_handler_types.h softdevice_handler.h softdevice_handler_appsh.h
  group source
    BLE_API/source/: BLE.cpp BLEInstanceBase.cpp DiscoveredCharacteristic.cpp GapScanningParams.cpp
    nRF51822/TARGET_NRF5/source/: nRF5xCharacteristicDescriptorDiscoverer.cpp nRF5xCharacteristicDescriptorDiscoverer.h nRF5xDiscoveredCharacteristic.cpp nRF5xDiscoveredCharacteristic.h nRF5xGap.cpp nRF5xGap.h nRF5xGattClient.cpp nRF5xGattClient.h nRF5xGattServer.cpp nRF5xGattServer.h nRF5xn.cpp nRF5xn.h nRF5xSecurityManager.h nRF5xServiceDiscovery.cpp nRF5xServiceDiscovery.h projectconfig.h
  group spi_master
    mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/drivers_nrf/spi_master/: nrf_drv_spi.h
  group spi_slave
    mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/drivers_nrf/spi_slave/: nrf_drv_spis.h
  group timer
    mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/drivers_nrf/timer/: nrf_drv_timer.h
  group trace
    mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/libraries/trace/: app_trace.h
  group twi_master
    mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/drivers_nrf/twi_master/: nrf_drv_twi.h
  group util
    mbed/TARGET_TY51822R3/TARGET_NORDIC/TARGET_NRF5/sdk/libraries/util/: app_error.h app_error_weak.h app_util.h app_util_bds.h app_util_platform.h common.h nordic_common.h nrf_assert.h nrf_log.h sdk_common.h sdk_errors.h sdk_macros.h sdk_mapped_flags.h sdk_os.h sdk_resources.h
